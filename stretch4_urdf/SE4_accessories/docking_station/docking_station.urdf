Commit message: Make contact link virtual

File: stretch4_urdf/SE4_accessories/docking_station/docking_station.urdf (robot description, URDF)
Before this commit: robot URDF_FRANCIS_ASSEM_Docking_Station_V1, 5 links, 4 joints
Links:
- link contacts_link: mass 3.50739982324297 -> 1e-5; geometry 
